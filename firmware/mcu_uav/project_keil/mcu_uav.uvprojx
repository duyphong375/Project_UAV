# Keil uVision project mcu_uav.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: SN34F788F SONiX
  pack: SONiX.SN34F7_DFP.2.0.4
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x7DFFC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: mcu_uav +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\inc;..\inc\SONiX.SN34F7_DFP.2.0.4\Device\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x7dffc
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 6.1.1, Device:Startup 2.0.2
